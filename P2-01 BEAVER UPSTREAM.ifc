Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 07850418-9b39-42b4-8f87-bd49d1f03a6a, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: P2-01 BEAVER UPSTREAM.ifc
Time: 2025-10-19T13:34:37+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ITA) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto

# IfcBuildingStorey: Livello:Livello 1, Livello 1
LongName: Livello 1; Elevation: 0 mm
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello 1; ID tipo: 1899; Tipo: Livello 1
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Solido; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello 1

# IfcRailing: P2-01 BEAVER UPSTREAM_R23:P2-01 BEAVER UPSTREAM_R23, P2-01 BEAVER UPSTREAM_R23:P2-01 BEAVER UPSTREAM_R23:9899
In: Livello 1
Type - Material: Metal, <Unnamed>, wood, White
Type - Altro - Categoria: Ringhiere: Supporti; Nome famiglia: P2-01 BEAVER UPSTREAM_R23
Type - Costruzione - Altezza: 125 mm
Type - Dati identità - Acciaio CAM Strade: conforme; ASI: 0.8; Certificazione: crash test; Classe: P2; Classe Box Uscita: Z2; Connessione: N2BL-01; Costo: 7306.25; Descrizione: (colore); EPD: sì; GWP totale cradle to gate: 75.3 kgCO2eq/m; Installazione: Fondazione; Legno CAM Strade: CoC PEFC; Livello di Severità: A; Materiale: Acciaio S355J0WP e Legno lamellare GL24H; Modello: P2-01 BEAVER upstream; Nome del tipo: P2-01 BEAVER UPSTREAM_R23; Norma di Riferimento: ENV 1317-4; Prezzo di Capitolato: 7306.25; Prodotto: Terminale certificato; Produttore: Margaritelli Road Safety; Tipologia: Avvio; Unità di Misura: N; URL: https://margaritelli-rs.com/it/products/p2-01_beaver/; URL (certificati CE. DOP. manuali. schede tecniche. schemi): https://margaritelli-rs.com/it/products/p2-01_beaver/
Type - Pset_ManufacturerTypeInformation - Manufacturer: Margaritelli Road Safety
Pset_QuantityTakeOff - Reference: P2-01 BEAVER UPSTREAM_R23
Pset_RailingCommon - Reference: P2-01 BEAVER UPSTREAM_R23; IsExternal: no
Altro - Famiglia: P2-01 BEAVER UPSTREAM_R23; Famiglia e tipo: P2-01 BEAVER UPSTREAM_R23: P2-01 BEAVER UPSTREAM_R23; ID tipo: 9883; Tipo: P2-01 BEAVER UPSTREAM_R23
Vincoli - Gioco mano: 0 mm; Host: Livello : Livello 1; Livello: Livello 1; Offset da host: 0 mm; Sposta con gli elementi più vicini: no
Quote - Area: 9.2634 m2; Volume: 0.178043 m3
